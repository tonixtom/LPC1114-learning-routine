# Keil uVision project simulate_I2c_at24c02.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: simulate_I2c_AT24C02 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Code;.\LPC11XX;.\User;.\AT24C16
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group LPC11XX
    ./LPC11XX/: system_LPC11xx.c startup_LPC11xx.s LPC11xx.h
  group User
    ./User/: main.c
  group AT24C16
    ./AT24C16/: at24c16.c
  group Code
    ./Code/: i2c.c uart.c
