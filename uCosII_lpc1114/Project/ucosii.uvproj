# Keil uVision project ucosii.uvproj, settings and files
target ucosii (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ucosii +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\CM0;..\LPC11xx;..\uCOSII;..\uCOSII\cpu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Main
    ../Main/: main.c
  group CMSIS Fils
    ../LPC11xx/startup/: startup_LPC11xx.s
    ../LPC11xx/: system_LPC11xx.c
    ../CM0/: core_cm0.c
  group ucOSII
    ../uCOSII/: OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C
    ../uCOSII/cpu/: Os_cpu_c.c
  group Gpio
    ../GPIO/: GPIO.C
