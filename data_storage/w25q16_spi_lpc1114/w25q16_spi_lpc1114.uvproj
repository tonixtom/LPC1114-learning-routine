# Keil uVision project w25q16_spi_lpc1114.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: send_uart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\CFG;.\LPC11XX;.\User;.\W25Q16
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC11xx.s
  group LPC11XX
    ./LPC11XX/: system_LPC11xx.c
  group User
    ./User/: main.c
  group CFG
    ./CFG/: uart.c ssp.c
  group w25q16
    ./W25Q16/: w25q16.c
