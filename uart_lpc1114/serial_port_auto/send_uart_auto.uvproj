# Keil uVision project send_uart_auto.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RationUART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\code;.\LPC11XX;.\User
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./LPC11XX/: startup_LPC11xx.s
  group LPC11XX
    ./LPC11XX/: system_LPC11xx.c
  group User
    ./User/: main.c
  group code
    ./code/: uart.c
  group Readme
    ./User/: Readme.txt
