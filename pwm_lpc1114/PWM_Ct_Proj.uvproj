# Keil uVision project PWM_Ct_Proj.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: CT_Proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\ILI9325;.\MAIN;.\NXPLPC11XX;.\W25X16
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_LPC11xx.s
  group MAIN
    ./MAIN/: main.c
  group NXPLPC11XX
    ./NXPLPC11XX/: nxplpc11xx.c ssp.c ct.c
