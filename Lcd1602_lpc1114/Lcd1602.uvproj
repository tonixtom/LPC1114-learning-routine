# Keil uVision project Lcd1602.uvproj, settings and files
target Lcd_1602 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114/301 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: test_lcd +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartFile
    ./: startup_LPC11xx.s
  group Source
    ./: main.c
  group Common
    ./: SYSTEM_LPC11XX.C GPIO.C
  group Readme
    ./: Readme.txt
